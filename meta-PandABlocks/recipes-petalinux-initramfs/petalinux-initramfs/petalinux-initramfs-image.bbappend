
INITRAMFS_SCRIPTS:append = " panda-initramfs-module-pinit"

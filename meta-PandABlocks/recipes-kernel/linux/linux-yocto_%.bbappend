FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
        file://overlay_fs.cfg \
        "


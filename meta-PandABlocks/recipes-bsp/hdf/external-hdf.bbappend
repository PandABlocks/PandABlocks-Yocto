FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
 
HDF_BASE:PandaBlocks = "file://"
HDF_PATH:PandaBlocks = "panda_ps.xsa"
